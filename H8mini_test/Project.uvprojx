# Keil uVision project Project.uvprojx, settings and files
target H8mini (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: GD32F130G6 GigaDevice
  pack: Keil.GD32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x00008000) IRAM(0x20000000,0x00001000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER HARDWARE_H8MINI
  c misc: --fpmode=fast
  c include: ..\; ..\Peripherals\inc; ..\CMSIS; .\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../CMSIS/: core_cm3.c system_gd32f1x0.c
  group Start
    ../CMSIS/: startup_gd32f1x0.s
  group Peripherals
    ../Peripherals/src/: gd32f1x0_adc.c gd32f1x0_cec.c gd32f1x0_cmp.c gd32f1x0_crc.c gd32f1x0_dac.c gd32f1x0_dma.c gd32f1x0_exti.c gd32f1x0_fmc.c gd32f1x0_gpio.c gd32f1x0_i2c.c gd32f1x0_iwdg.c gd32f1x0_mcudbg.c gd32f1x0_misc.c gd32f1x0_pwr.c gd32f1x0_rcc.c gd32f1x0_rtc.c gd32f1x0_spi.c gd32f1x0_syscfg.c gd32f1x0_timer.c gd32f1x0_tsi.c gd32f1x0_usart.c gd32f1x0_wwdg.c
  group src
    ./src/: control.c led.c rgb_led.c buzzer.c main.c rx_bayang_protocol.c rx_bayang_ble.c rx_bayang_ble_app.c sixaxis.c filter.cpp imu.c gestures.c flip_sequencer.c flash.c util.c pid.c stickvector.c angle_pid.c defines.h config.h hardware.h rx_fq777-124.c sixaxis_bmi055.c bmi055.h hardware_fq777-124.h hardware_h8mini.h
  group drv
    ./src/: drv_adc.c drv_clk.c drv_gpio.c drv_esc.c drv_pwm.c drv_dshot.c drv_serial.c drv_softi2c.c drv_spi.c drv_time.c drv_xn297.c drv_i2c.c drv_fmc1.c drv_rgb.c drv_servo.c
  group misc
    ./src/: binary.h macros.h
target FQ777-124 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: GD32F130G6 GigaDevice
  pack: Keil.GD32F1xx_DFP.1.1.0
  cpu: as above
  output: Project +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER HARDWARE_FQ777_124
  c misc: --fpmode=fast
  c include: ..\; ..\Peripherals\inc; ..\CMSIS; .\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
